# Keil uVision project f103c6t6_usb_3_keys_board.uvprojx, settings and files
target f103c6t6_usb_3_keys_board (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: f103c6t6_usb_3_keys_board +hex
  AfterMake: D:\MDK5\UV4\UV4.exe -f d:\stm32_file\cubemx\f103c6t6_usb_3_keys_board\MDK-ARM\f103c6t6_usb_3_keys_board.uvprojx -j0 -t f103c6t6_usb_3_keys_board -o d:\stm32_file\cubemx\f103c6t6_usb_3_keys_board\MDK-ARM\.vscode\uv4.log
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Core/Inc;       ../USB_DEVICE/App;       ../USB_DEVICE/Target;       ../Drivers/STM32F1xx_HAL_Driver/Inc;       ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;       ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;       ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;       ../Drivers/CMSIS/Include;       ..\hid_dev;       ..\other\MultiButton-master;       ..\other\ringbuffer;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Inc/: pid.c psk_ps.c psk_led.c psk_switch.c
    ../other/MultiButton-master/: multi_button.c
    ../other/ringbuffer/: lwrb.c
    ../Core/Src/: main.c gpio.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group hid_dev
    ../hid_dev/: custom_control.c keyboard.c mouse.c touch_screen.c psk_hid.c
software components: CMSIS:CORE 4.3.0
